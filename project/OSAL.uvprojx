# Keil uVision project OSAL.uvprojx, settings and files
target OSAL (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OSAL
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\bsp;..\hal;..\osal;..\mcu\inc;..\mcu\inc\startup\arm;..\app
  asm include: ..\mcu\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: app_control.c
  group main
    ../main/: main.c
  group osal
    ../osal/: osal.c osal_task.c osal_timer.c
  group hal
    ../hal/: hal.c hal_lamp.c
  group bsp
    ../bsp/: bsp.c bsp_lamp.c
  group mcu
    ../mcu/src/: core_cm3.c misc.c stm32f10x_gpio.c mcu.c stm32f10x_rcc.c stm32f10x_it.c
    ../mcu/inc/startup/arm/: startup_stm32f10x_hd.s
    ../mcu/inc/: system_stm32f10x.c
